* Common Emitter Amplifier Circuit

V1 N001 0 10
V2 N006 0 AC(1 35)
R1 N001 N002 2k
R2 N002 N003 300k
R3 N004 0 1k
R4 N005 0 300k
Q1 N002 N003 N004 NPN
C1 N002 N005 1u
C2 N003 N006 1u
C3 N004 0 10n

.ac dec 200 10 100k
